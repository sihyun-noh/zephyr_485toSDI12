# Repository sihyun-noh/zephyr_485toSDI12

File README.md:

# Dajilog Zephyr Device Firmware

Zephyr RTOS 기반 Dajilog MCU 장비의 firmware, custom board 정의, 공통 component,
KiCad hardware source를 함께 관리하는 repository입니다.

현재 STM32G431 기반 `dajilog_tech`, `agmo_tic` 보드와 RS-485, SDI-12, CAN,
USB CDC, I2C/OLED, ADS1232, SBUS, digital I/O bring-up 결과를 포함합니다.

## Repository map

```text
app/                         Product/application firmware
  dajilog_scale/             Load-cell scale, ADS1232, OLED, CAN calibration
  dajilog_485_to_sdi12/      RS-485 Modbus sensor to SDI-12 slave bridge
  agmo_tic/                  AGMO tractor ignition-control FSM
  dajilog_tech_test/         dajilog_tech hardware bring-up test
boards/                      Dajilog custom Zephyr board definitions
components/                  Reusable peripheral, protocol, and service modules
hardware/kicad/              KiCad schematic, PCB, production source
scripts/                     OpenOCD option-byte and flash helper scripts
tools/dajilog_provisioner/   macOS USB CDC provisioning GUI
```

`build*` directories are local Zephyr/CMake output and intentionally ignored by Git.

## Quick start

```bash
cd /path/to/example-application
source ~/zephyrproject/.venv/bin/activate

# dajilog_scale
west build -p always -b dajilog_tech app/dajilog_scale -d build_dajilog_scale \
  -- -DEXTRA_CONF_FILE=profiles/scale_default.conf
west flash -d build_dajilog_scale

# RS-485 to SDI-12 bridge, default sensor profile
west build -p always -b dajilog_tech app/dajilog_485_to_sdi12 \
  -d build_dajilog_485_to_sdi12_default \
  -- -DEXTRA_CONF_FILE=profiles/sensor_default.conf
west flash -d build_dajilog_485_to_sdi12_default

# AGMO TIC
west build -p always -b agmo_tic app/agmo_tic -d build_agmo_tic
west flash -d build_agmo_tic

# dajilog_tech bring-up test
west build -p always -b dajilog_tech app/dajilog_tech_test -d build_dajilog_tech_test
west flash -d build_dajilog_tech_test
```

The application CMake files pin board-specific apps to their safe target board where
needed. Do not reuse a build directory for a different board or app.

### Profile build helpers

The same build commands are available as scripts. Source the Zephyr virtual environment first.

```bash
./scripts/build_dajilog_scale.sh
./scripts/build_dajilog_scale.sh flash

./scripts/build_dajilog_485_to_sdi12.sh
./scripts/build_dajilog_485_to_sdi12.sh flash
```

Select a product variant without changing source code by overriding `PROFILE` and,
when needed, use a separate `BUILD_DIR`.

```bash
PROFILE=profiles/scale_default.conf BUILD_DIR=build_scale_v01 \
  ./scripts/build_dajilog_scale.sh
```

## 개발 기준

```text
RTOS: Zephyr
Zephyr version: v3.7.0 LTS
Workspace topology: T2, application manifest repository
Application path: example-application
```

## Workspace

현재 workspace 구조:

```text
my-workspace/
├── .west/
├── example-application/   # this project
├── zephyr/                # Zephyr v3.7.0
└── modules/
```

현재 application 경로:

```text
/Users/sihyun.noh/project/zephyr_workspace/my-workspace/example-application
```

## Python / west 환경

Zephyr 개발용 Python 가상환경:

```bash
source ~/zephyrproject/.venv/bin/activate
```

확인:

```bash
which west
west --version
west topdir
west list zephyr
```

현재 확인된 환경:

```text
west: /Users/sihyun.noh/zephyrproject/.venv/bin/west
west version: v1.4.0
zephyr revision: v3.7.0
```

## Hardware

KiCad 회로도는 firmware repository 안에서 함께 관리합니다.

```text
hardware/kicad/485toSDI12/
├── 485toSDI12.kicad_pro
├── 485toSDI12.kicad_sch
└── 485toSDI12.kicad_pcb
```

회로도와 Zephyr 설정은 함께 관리합니다.

```text
KiCad MCU pin
  -> Zephyr devicetree overlay
  -> driver / peripheral config
  -> board bring-up
```

## Reference board: dajilog_tech

초기 Zephyr bring-up은 dajilog_tech 회로도를 참조해서 진행합니다.

```text
Board definition:
boards/dajilog_tech/dajilog_tech/

Test application:
app/dajilog_tech_test/
```

현재 매핑:

```text
MCU: STM32G431C8
LED0: PA15, active low
LED1: PA0, active low
USB: PA11 DM, PA12 DP
CAN: PB8 RX, PB9 TX
Debug: SWD through J-Link/OpenOCD
```

빌드:

```bash
source ~/zephyrproject/.venv/bin/activate
west build -b dajilog_tech app/dajilog_tech_test -p always
```

새 보드 최초 1회 BOOT0 option byte 설정:

```bash
./scripts/provision_stm32g431_boot0.sh
```

이 보드는 `PB8`을 `CANFD_RX`로 사용하지만, STM32G431에서 `PB8`은 `BOOT0` 기능도 가진다.
새 MCU의 option byte가 BOOT0 pin을 따르는 상태이면 reset 순간 PB8 상태에 따라 system bootloader로 들어갈 수 있다.
따라서 새 보드는 firmware flash 전에 최초 1회 아래 설정을 적용한다.

```text
nSWBOOT0 = 0  -> BOOT0 pin 무시, option byte 사용
nBOOT0   = 1  -> Main Flash boot
OPTR     = 0xfbeff8aa
```

주의:

```text
이 설정은 일반 application firmware가 아니라 MCU 내부 option byte 설정이다.
전원 off 후에도 유지되므로 매번 west flash 전에 실행할 필요는 없다.
새 보드 / 새 MCU / option byte 초기화 후에만 다시 실행한다.
```

Flash:

```bash
west flash
```

Flash 후 사용률까지 확인:

```bash
./scripts/flash_with_usage.sh
```

출력 예:

```text
** Programming Finished **
verified 53936 bytes in 0.411011s (128.152 KiB/s)
FLASH usage: 53936 B / 131072 B (41.15%)
```

현재 확인된 빌드 결과:

```text
Zephyr: v3.7.0
SDK: 0.16.8
FLASH: 53356 B / 128 KB
RAM: 14464 B / 32 KB
```

## Debug / Flash

현재 J-Link와 OpenOCD를 사용합니다.

OpenOCD 설치 확인:

```bash
which openocd
openocd --version
```

J-Link + STM32G4 연결 확인 예:

```bash
openocd \
  -f interface/jlink.cfg \
  -c "adapter serial 000788529183" \
  -c "transport select swd" \
  -f target/stm32g4x.cfg \
  -c "init" \
  -c "targets" \
  -c "shutdown"
```

칩 정보 확인 예:

```bash
openocd \
  -f interface/jlink.cfg \
  -c "adapter serial 000788529183" \
  -c "transport select swd" \
  -f target/stm32g4x.cfg \
  -c "init" \
  -c "reset halt" \
  -c "flash probe 0" \
  -c "shutdown"
```

현재 `west flash`는 보드 전용 OpenOCD 설정을 사용한다.

```text
boards/dajilog_tech/dajilog_tech/support/openocd.cfg
```

현재 reset 방식:

```text
cortex_m reset_config sysresetreq
```

이 방식은 현재 보드에서 `program` / `verify` / reset 후 실행이 안정적으로 동작했다.

## USB CDC

USB CDC는 MCU를 Mac에서 가상 시리얼 포트처럼 보이게 하는 기능입니다.

Mac에서 확인:

```bash
ls /dev/cu.*
```

접속 예:

```bash
screen /dev/cu.usbmodemXXXX 115200
```

### Device provisioning

`dajilog_scale` provides a common USB CDC shell for installing a CAN node ID in
the EEPROM Device Profile. The Zephyr built-in `device` shell is disabled in this
app so the following Dajilog commands own the `device` namespace.

```text
device info
device profile get
device node set <1..127>
device reboot
```

After `device node set 13` and reboot, Device Info uses request ID `0x60D` and
response ID `0x58D`. The STM32 96-bit chip UID is read directly from hardware and
is shown by `device info`; it is not stored in EEPROM.

For a direct USB provisioning GUI on macOS:

```bash
cd tools/dajilog_provisioner
./install.sh
./run.sh
```

## Common CAN Device Info

All Dajilog applications can use the common node-addressed Device Info protocol.

```text
request  = 0x600 + node_id
response = 0x580 + node_id
```

Supported queries include basic identity, firmware, product serial, runtime health,
and the three parts of the STM32 96-bit UID. The detailed frame definition lives in
`components/dajilog_device_info/` and the project CAN design document.

## 다음 작업

```text
1. dajilog_tech_V0.1 회로도 기준 MCU pin 정리
2. Zephyr board 또는 devicetree overlay 작성
3. 기본 blinky / hello_world 빌드
4. OpenOCD + J-Link flash 확인
5. USB CDC console 확인
6. RS-485 / SDI-12 driver bring-up
```

## KiCad design hardware/kicad/agmo/12-Channel_Ejection_Controller/12-Channel_Ejection_Controller.kicad_pcb

Parts:
C18: 220uF/50V; CP_Elec_10x10; LCSC C125976
C19, C24, C30: 1uF; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
C20: 10uF/50V; C_1812_4532Metric
C21: 4.7uF/50V; C_1812_4532Metric
C23, C29: 100nF; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
C25: 10nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C26: 4.7uF; C_0805_2012Metric
C27: 220uF; CP_EIA-7343-31_Kemet-D; LCSC C130380
C28, C32, C34: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C1779
C31: 4.7uF; C_0805_2012Metric; LCSC C1779
C33: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C1779
C54: 100nF; C_0805_2012Metric
CN1: ( - ) POWER ( + ); PhoenixContact_MSTBA_2,5_2-G-5,08_1x02_P5.08mm_Horizontal; LCSC C395737
D2, D72: LED RED; LED_0805_2012Metric
D3: BZT52C15; D_SOD-123
D4: SMCJ18AC; D_SMC; LCSC C374030
D5: LED RED; LED_0805_2012Metric; not fitted
D6: B340; D_SMB; LCSC C3018525
F2: 0466005.NRHF; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder; LCSC C57525
L1: 22uH; L_APV_APH0630; LCSC C5349702
Q1: SQ2361CEES-T1_GE3; SOT-23; LCSC C29267586
R5, R6, R107: 4.7k; R_0805_2012Metric
R7, R10, R11: 10k; R_0805_2012Metric
R8: 100k; R_0805_2012Metric; not fitted
R9: 4.7k; R_0805_2012Metric; not fitted
R12: 3.24k; R_0805_2012Metric
U4, U6: AP2112K-3.3; SOT-23-5; LCSC C51118
U5: TPS5430DDA; TI_SO-PowerPAD-8_ThermalVias; LCSC C9864
U7: B0505S-3W; Converter_DCDC_TRACO_TBA2-xxxx_Single_THT; LCSC C7465195

Connections:
+3.3V: C23.2, C24.2, R9.2, U4.5 (VOUT); also elsewhere on the board
+5V: C19.2, C27.1, C28.1, C31.1, C32.1, L1.2, R5.2, R7.1, R11.1, U4.1 (VIN), U7.1 (+Vin); also elsewhere on the board
D_GND: C18.2, C19.1, C20.2, C21.2, C23.1, C24.1, C27.2, C28.2, C31.2, C32.2, C54.2, CN1.1, D2.1 (K), D4.2 (A2), D5.1 (K), D6.2 (A), R6.2, R12.2, U4.2 (GND), U5.6 (GND), U5.9 (GNDPAD), U7.2 (-Vin); also elsewhere on the board
D_VIN: CN1.2, F2.1; also elsewhere on the board
ISO_3.3V: C29.2, C30.2, U6.5 (VOUT); also elsewhere on the board
ISO_5V: C26.2, C33.1, C34.1, R10.1, R107.2, U6.1 (VIN), U7.6 (+Vout); also elsewhere on the board
unnamed: D2.2 (A), R5.1
unnamed: D3.2 (A), Q1.1 (G), R6.1
unnamed: C18.1, C20.1, C21.1, C54.1, D3.1 (K), Q1.2 (S), R8.2, U5.7 (VIN)
unnamed: D4.1 (A1), F2.2, Q1.3 (D)
unnamed: D5.2 (A), R9.1
unnamed: C25.2, D6.1 (K), L1.1, U5.8 (PH)
unnamed: D72.2 (A), R107.1
unnamed: R7.2, U4.3 (EN)
unnamed: C25.1, U5.1 (BOOT)
unnamed: R8.1, U5.5 (EN)
unnamed: R11.2, R12.1, U5.4 (VSENSE)
unnamed: R10.2, U6.3 (EN)
SGND: C26.1, C29.1, C30.1, C33.2, C34.2, D72.1 (K), U6.2 (GND), U7.4 (-Vout); also elsewhere on the board

Notes on the sheet:
ISO 3.3V Reguator
600mA
3.3V Reguator
12V input
STM32G473 + 주변회로 150 mA SSD1309 OLED 100 mA USB 50 mA EEPROM/I2C/Encoder 30 mA Digital isolator 20 mA Opto MCU side 30 mA 기타 30 mA --------------------------------- Worst-case budget 410 mA

Parts:
C2, C6, C7, C8, C9, C12, C53: 100nF; C_0603_1608Metric
C3, C5, C10, C15, C16, C17: 100nF; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
C11: 1uF; C_0603_1608Metric
C13, C14: 22pF; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
D1: 1N5819; D_SOD-123
F1: MF-PSMF050X-2; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C116170
FB1: 600Ω @ 100MHz; L_0805_2012Metric
J1: SSD1309; PinHeader_1x04_P2.54mm_Vertical
J2: encoder-key; PinHeader_1x05_P2.54mm_Vertical
J3: Debug; PinHeader_1x04_P2.54mm_Vertical
R1, R2: 10k; R_0805_2012Metric
R3, R4: 4.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: NRST; SW_Tactile_SPST_NO_Straight_CK_PTS636Sx25SMTRLFS; LCSC C42420257
U1: STM32G473RCT6; LQFP-64_10x10mm_P0.5mm; MPN STM32G473RCT6; LCSC C529361
U2: USBLC6-2SC6; SOT-23-6; LCSC C2827654
U3: AT24C256C-SSHL; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C615461
USB1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_G-Switch_GT-USB-7051x; LCSC C2843970
Y2: 8Mhz; Crystal_SMD_HC49-SD; LCSC C12674

Connections:
/main Sheet/NRST: C5.2, SW1.2, U1.7 (PG10)
CANFD_RX: U1.61 (PB8); also elsewhere on the board
CANFD_TX: U1.62 (PB9); also elsewhere on the board
ENC_A: J2.3, U1.38 (PC6)
ENC_B: J2.2, U1.39 (PC7)
ENC_SW: J2.4, U1.42 (PA8)
I2C3_SCL: J1.2, R4.2, U1.40 (PC8), U3.6 (SCL)
I2C3_SDA: J1.3, R3.2, U1.41 (PC9), U3.5 (SDA)
ISO_3.3V: C2.1, C3.2, C6.1, C7.1, C8.1, C10.2, C12.1, C15.2, C16.1, C53.1, FB1.2, J1.4, J2.5, J3.4, R3.1, R4.1, U1.1 (VBAT), U1.16 (VDD), U1.28 (VREF+), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U3.8 (VCC); also elsewhere on the board
ISO_5V: D1.1 (K), U2.5 (VBUS); also elsewhere on the board
ISO_A3.3V: C9.1, C11.1, FB1.1, U1.29 (VDDA)
ISO_DI1: U1.12 (PA0); also elsewhere on the board
ISO_DI2: U1.13 (PA1); also elsewhere on the board
ISO_DI3: U1.14 (PA2); also elsewhere on the board
ISO_DI4: U1.17 (PA3); also elsewhere on the board
ISO_DI5: U1.60 (PB7); also elsewhere on the board
ISO_DI6: U1.59 (PB6); also elsewhere on the board
ISO_DI7: U1.58 (PB5); also elsewhere on the board
ISO_DI8: U1.57 (PB4); also elsewhere on the board
ISO_DI9: U1.51 (PA15); also elsewhere on the board
ISO_DI10: U1.54 (PC12); also elsewhere on the board
ISO_DI11: U1.53 (PC11); also elsewhere on the board
ISO_DI12: U1.52 (PC10); also elsewhere on the board
ISO_DI13: U1.2 (PC13); also elsewhere on the board
ISO_DI14: U1.3 (PC14); also elsewhere on the board
ISO_DO1: U1.8 (PC0); also elsewhere on the board
ISO_DO2: U1.9 (PC1); also elsewhere on the board
ISO_DO3: U1.10 (PC2); also elsewhere on the board
ISO_DO4: U1.11 (PC3); also elsewhere on the board
ISO_DO5: U1.18 (PA4); also elsewhere on the board
ISO_DO6: U1.19 (PA5); also elsewhere on the board
ISO_DO7: U1.20 (PA6); also elsewhere on the board
ISO_DO8: U1.21 (PA7); also elsewhere on the board
ISO_DO9: U1.22 (PC4); also elsewhere on the board
ISO_DO10: U1.23 (PC5); also elsewhere on the board
ISO_DO11: U1.24 (PB0); also elsewhere on the board
ISO_DO12: U1.25 (PB1); also elsewhere on the board
unnamed: C17.2, D1.2 (A), F1.2
unnamed: U2.1 (I/O1), USB1.A7 (D-), USB1.B7 (D-)
unnamed: U2.3 (I/O2), USB1.A6 (D+), USB1.B6 (D+)
unnamed: R1.1, USB1.A5 (CC1)
unnamed: R2.1, USB1.B5 (CC2)
OSC_IN: C13.2, U1.5 (PF0), Y2.2
OSC_OUT: C14.2, U1.6 (PF1), Y2.1
RXD1: U1.44 (PA10)
SGND: C2.2, C3.1, C5.1, C6.2, C7.2, C8.2, C9.2, C10.1, C11.2, C12.2, C13.1, C14.1, C15.1, C16.2, C17.1, C53.2, J1.1, J2.1, J3.1, R1.2, R2.2, SW1.1, U1.15 (VSS), U1.27 (VSSA), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS), U2.2 (GND), U3.1 (A0), U3.2 (A1), U3.3 (A2), U3.4 (GND), USB1.A1 (GND), USB1.A12 (GND), USB1.B1 (GND), USB1.B12 (GND), USB1.SH (SHIELD); also elsewhere on the board
SWCLK: J3.2, U1.50 (PA14)
SWDIO: J3.3, U1.49 (PA13)
TXD1: U1.43 (PA9)
USB D+: U1.46 (PA12), U2.4 (I/O2)
USB D-: U1.45 (PA11), U2.6 (I/O1)
VUSB: F1.1, USB1.A4 (VBUS), USB1.A9 (VBUS), USB1.B4 (VBUS), USB1.B9 (VBUS)

Notes on the sheet:
USB C-type
MCU DECOUPLING / ANALOG SUPPLY
crystal
EEPROM
HSE: 8 MHz, CL=8 pF (initial)
C1/C2: 12 pF — verify vs selected crystal MPN
SWD

Parts:
CN5: (-) OUT_AUX (+); PhoenixContact_MSTBA_2,5_2-G-5,08_1x02_P5.08mm_Horizontal; LCSC C395737
D35, D36, D37, D38, D39, D50, D51, D52, D53, D54, D65, D66: LED RED; LED_0805_2012Metric
D40, D41, D42, D43, D44, D55, D56, D57, D58, D59, D67, D68: SMAJ30CA; D_SMA
D45, D46, D47, D48, D49, D60, D61, D62, D63, D64, D69, D70: BZT52C15; D_SOD-123
J7: CH1 CH2 ( - ) ( + ); PhoenixContact_MSTBA_2,5_4-G-5,08_1x04_P5.08mm_Horizontal; LCSC C395753
J8: CH7 CH8 ( - ) ( + ); PhoenixContact_MSTBA_2,5_4-G-5,08_1x04_P5.08mm_Horizontal; LCSC C395753
J9: CH3 CH4 ( - ) ( + ); PhoenixContact_MSTBA_2,5_4-G-5,08_1x04_P5.08mm_Horizontal; LCSC C395753
J10: CH9 CH10 ( - ) ( + ); PhoenixContact_MSTBA_2,5_4-G-5,08_1x04_P5.08mm_Horizontal; LCSC C395753
J11: CH5 CH6 ( - ) ( + ); PhoenixContact_MSTBA_2,5_4-G-5,08_1x04_P5.08mm_Horizontal; LCSC C395753
J12: CH11 CH12 ( - ) ( + ); PhoenixContact_MSTBA_2,5_4-G-5,08_1x04_P5.08mm_Horizontal; LCSC C395753
Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13: DMP10H400SK3-13; TO-252-2; LCSC C177034
R69, R70, R71, R72, R73, R84, R85, R86, R87, R88, R99, R100: 1k; R_0805_2012Metric
R74, R75, R76, R77, R78, R89, R90, R91, R92, R93, R101, R102: 4.7k; R_0805_2012Metric
R79, R80, R81, R82, R83, R94, R95, R96, R97, R98, R103, R104: 22k; R_0805_2012Metric
U22, U23, U24, U25, U26, U27, U28, U29, U30, U31, U32, U33: TLP293; SOIC-4_4.55x2.6mm_P1.27mm; LCSC C77656

Connections:
24V+: CN5.2, D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D60.1 (K), D61.1 (K), D62.1 (K), D63.1 (K), D64.1 (K), D69.1 (K), D70.1 (K), Q2.3 (S), Q3.3 (S), Q4.3 (S), Q5.3 (S), Q6.3 (S), Q7.3 (S), Q8.3 (S), Q9.3 (S), Q10.3 (S), Q11.3 (S), Q12.3 (S), Q13.3 (S), R79.2, R80.2, R81.2, R82.2, R83.2, R94.2, R95.2, R96.2, R97.2, R98.2, R103.2, R104.2
24V-: CN5.1, D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (A1), D41.1 (A1), D42.1 (A1), D43.1 (A1), D44.1 (A1), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (A1), D56.1 (A1), D57.1 (A1), D58.1 (A1), D59.1 (A1), D65.1 (K), D66.1 (K), D67.1 (A1), D68.1 (A1), J7.1, J7.3, J8.1, J8.3, J9.1, J9.3, J10.1, J10.3, J11.1, J11.3, J12.1, J12.3, U22.3, U23.3, U24.3, U25.3, U26.3, U27.3, U28.3, U29.3, U30.3, U31.3, U32.3, U33.3
/output_iso Sheet/SOL_CH1: D44.2 (A2), J7.2, Q6.2 (D), R78.1
/output_iso Sheet/SOL_CH2: D59.2 (A2), J7.4, Q11.2 (D), R93.1
/output_iso Sheet/SOL_CH3: D67.2 (A2), J9.2, Q12.2 (D), R101.1
/output_iso Sheet/SOL_CH4: D40.2 (A2), J9.4, Q2.2 (D), R74.1
/output_iso Sheet/SOL_CH5: D55.2 (A2), J11.2, Q7.2 (D), R89.1
/output_iso Sheet/SOL_CH6: D68.2 (A2), J11.4, Q13.2 (D), R102.1
/output_iso Sheet/SOL_CH7: D41.2 (A2), J8.2, Q3.2 (D), R75.1
/output_iso Sheet/SOL_CH8: D56.2 (A2), J8.4, Q8.2 (D), R90.1
/output_iso Sheet/SOL_CH9: D42.2 (A2), J10.2, Q4.2 (D), R76.1
/output_iso Sheet/SOL_CH10: D57.2 (A2), J10.4, Q9.2 (D), R91.1
/output_iso Sheet/SOL_CH11: D43.2 (A2), J12.2, Q5.2 (D), R77.1
/output_iso Sheet/SOL_CH12: D58.2 (A2), J12.4, Q10.2 (D), R92.1
ISO_DO1: R73.1; also elsewhere on the board
ISO_DO2: R88.1; also elsewhere on the board
ISO_DO3: R99.1; also elsewhere on the board
ISO_DO4: R69.1; also elsewhere on the board
ISO_DO5: R84.1; also elsewhere on the board
ISO_DO6: R100.1; also elsewhere on the board
ISO_DO7: R70.1; also elsewhere on the board
ISO_DO8: R85.1; also elsewhere on the board
ISO_DO9: R71.1; also elsewhere on the board
ISO_DO10: R86.1; also elsewhere on the board
ISO_DO11: R72.1; also elsewhere on the board
ISO_DO12: R87.1; also elsewhere on the board
unnamed: D35.2 (A), R74.2
unnamed: D36.2 (A), R75.2
unnamed: D37.2 (A), R76.2
unnamed: D38.2 (A), R77.2
unnamed: D39.2 (A), R78.2
unnamed: D45.2 (A), Q2.1 (G), R79.1, U22.4
unnamed: D46.2 (A), Q3.1 (G), R80.1, U23.4
unnamed: D47.2 (A), Q4.1 (G), R81.1, U24.4
unnamed: D48.2 (A), Q5.1 (G), R82.1, U25.4
unnamed: D49.2 (A), Q6.1 (G), R83.1, U26.4
unnamed: D50.2 (A), R89.2
unnamed: D51.2 (A), R90.2
unnamed: D52.2 (A), R91.2
unnamed: D53.2 (A), R92.2
unnamed: D54.2 (A), R93.2
unnamed: D60.2 (A), Q7.1 (G), R94.1, U27.4
unnamed: D61.2 (A), Q8.1 (G), R95.1, U28.4
unnamed: D62.2 (A), Q9.1 (G), R96.1, U29.4
unnamed: D63.2 (A), Q10.1 (G), R97.1, U30.4
unnamed: D64.2 (A), Q11.1 (G), R98.1, U31.4
unnamed: D65.2 (A), R101.2
unnamed: D66.2 (A), R102.2
unnamed: D69.2 (A), Q12.1 (G), R103.1, U32.4
unnamed: D70.2 (A), Q13.1 (G), R104.1, U33.4
unnamed: R69.2, U22.1
unnamed: R70.2, U23.1
unnamed: R71.2, U24.1
unnamed: R72.2, U25.1
unnamed: R73.2, U26.1
unnamed: R84.2, U27.1
unnamed: R85.2, U28.1
unnamed: R86.2, U29.1
unnamed: R87.2, U30.1
unnamed: R88.2, U31.1
unnamed: R99.2, U32.1
unnamed: R100.2, U33.1
SGND: U22.2, U23.2, U24.2, U25.2, U26.2, U27.2, U28.2, U29.2, U30.2, U31.2, U32.2, U33.2; also elsewhere on the board

Notes on the sheet:
BAT(-)
BAT(+)
P-MOSFET High-side switch

Parts:
C49, C50, C51, C52: 100nF; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
CN4: (H) CAN (L); PhoenixContact_MSTBA_2,5_2-G-5,08_1x02_P5.08mm_Horizontal; LCSC C395737
D71: SM24CANB-02HTG; SOT-23
FL1: ACT45B-510-2P-TL003; FIL_ACT45B-510-2P-TL003; LCSC C76584
R105: 0/J; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R106: 120; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U34: π142M31; SOIC-16_3.9x9.9mm_P1.27mm; LCSC C471606
U35: TJA1051T-3; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C38695

Connections:
+3.3V: C51.1, C52.1, U34.16 (VDD2), U35.5 (VIO); also elsewhere on the board
+5V: C50.1, U35.3 (VCC); also elsewhere on the board
/interface Sheet/CAN_H: CN4.1, D71.2 (A2), FL1.4, R106.2
/interface Sheet/CAN_L: CN4.2, D71.1 (A1), FL1.3, R106.1
/interface Sheet/ISO_CAN_RXD: U34.11 (B4), U35.4 (RXD)
/interface Sheet/ISO_CAN_TXD: U34.13 (B2), U35.1 (TXD)
CANFD_RX: U34.6 (A4); also elsewhere on the board
CANFD_TX: U34.4 (A2); also elsewhere on the board
D_GND: C50.2, C51.2, C52.2, D71.3 (common), R105.1, U34.9 (GND2), U34.15 (GND2), U35.2 (GND); also elsewhere on the board
ISO_3.3V: C49.1, U34.1 (VDD1); also elsewhere on the board
unnamed: FL1.1, U35.7 (CANH)
unnamed: FL1.2, U35.6 (CANL)
unnamed: R105.2, U35.8 (S)
SGND: C49.2, U34.2 (GND1), U34.8 (GND1); also elsewhere on the board

Notes on the sheet:
CAN
